# Keil uVision project FSST15_MeteorLamp.uvproj, settings and files
target FSST15_MeteorLamp (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: FSST15_MeteorLamp +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\FsBSP\inc;..\FsBSP\src;..\RTX51 tiny;..\STCLib\inc;..\STCLib\src;..\USER
  link misc: REMOVEUNUSED
  group FsBSP
    ../FsBSP/src/: FsBSP_AllLedFlash.c
  group STCLib
    ../STCLib/src/: stc15_gpio.c
  group USER
    ../USER/: RTX51_MeteorLamp.c
  group RTX51
    ../RTX51 tiny/: Conf_tny.A51
  group Doc
    ../: 说明.txt
