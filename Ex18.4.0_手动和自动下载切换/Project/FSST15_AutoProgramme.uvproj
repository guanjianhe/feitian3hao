# Keil uVision project FSST15_AutoProgramme.uvproj, settings and files
target FSST15_AutoProgramme (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: FSST15_AutoProgramme +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\FsBSP\inc;..\FsBSP\src;..\STCLib\inc;..\STCLib\src;..\USER
  link misc: REMOVEUNUSED
  group STCLib
    ../STCLib/src/: stc15_timer.c stc15_exti.c stc15_delay.c stc15_gpio.c
  group USER
    ../USER/: main.c
  group Doc
    ../: 说明.txt
