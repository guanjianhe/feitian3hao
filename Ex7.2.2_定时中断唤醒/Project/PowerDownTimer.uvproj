# Keil uVision project PowerDownTimer.uvproj, settings and files
target PowerDownTimer (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: PowerDownTimer +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\FsBSP\inc;..\FsBSP\src;..\Project;..\STCLib;..\USER
  group FsBSP
    ../FsBSP/src/: FsBSP_AllLedFlash.c FsBSP_Timer.c
  group STCLib
    ../STCLib/: STC15.H
  group USER
    ../USER/: main.c
  group Project
    ./: STARTUP.A51
