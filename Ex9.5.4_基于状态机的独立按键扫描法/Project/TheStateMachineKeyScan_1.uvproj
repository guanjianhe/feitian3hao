# Keil uVision project TheStateMachineKeyScan_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: TheStateMachineKeyScan_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\FsBSP\inc;..\FsBSP\src;..\Project;..\STCLib;..\USER
  group Project
    ./: STARTUP.A51
  group FsBSP
    ../FsBSP/src/: FsBSP_Delay.c FsBSP_Key.c FsBSP_AllLedFlash.c
  group USER
    ../USER/: main.c
  group STCLib
    ../STCLib/: STC15.H
