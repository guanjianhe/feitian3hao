# Keil uVision project Touch_KEY_Demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Touch_KEY_Demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\FsBSP\inc;..\FsBSP\src;..\Project;..\STCLib\inc;..\STCLib\src;..\USER
  group Project
    ./: STARTUP.A51
  group STCLib
    ../STCLib/inc/: STC15_FS.H stc15_ClkVarType.h
    ../STCLib/src/: stc15_delay.c
  group USER
    ../USER/: main.c
  group FsBSP
    ../FsBSP/src/: FsBSP_Timer.c FsBSP_Adc.c
