# Keil uVision project ADC_KEY_Demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: ADC_KEY_Demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\FsBSP\inc;..\FsBSP\src;..\Project;..\USER;..\STCLib\inc;..\STCLib\src
  link misc: REMOVEUNUSED
  group Project
    ./: STARTUP.A51
  group USER
    ../USER/: BSP_Include.h main.c
  group STCLib
    ../STCLib/src/: stc15_gpio.c stc15_adc.c stc15_delay.c
    ../STCLib/inc/: STC15_FS.H stc15_ClkVarType.h
  group FsBSP
    ../FsBSP/src/: FsBSP_1602.c
