# Keil uVision project ADC_Demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: ADC_Demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\FsBSP\inc;..\FsBSP\src;..\Project;..\STCLib\inc;..\STCLib\src;..\USER
  link misc: REMOVEUNUSED
  group Project
    ./: STARTUP.A51
  group STCLib
    ../STCLib/src/: stc15_adc.c stc15_gpio.c stc15_delay.c
  group FsBSP
    ../FsBSP/src/: FsBSP_1602.c
  group USER
    ../USER/: main.c
