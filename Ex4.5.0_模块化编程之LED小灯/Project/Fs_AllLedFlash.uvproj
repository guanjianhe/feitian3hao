# Keil uVision project Fs_AllLedFlash.uvproj, settings and files
target FsST15 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Fs_AllLedFlash +hex
  c flags: Optimize=8 SizeSpeed=1
  group FsBSP
    ../FsBSP/src/: FsBSP_AllLedFlash.c FsBSP_Delay.c
  group USER
    ../USER/: main.c
  group Doc
    ../: 说明.txt
