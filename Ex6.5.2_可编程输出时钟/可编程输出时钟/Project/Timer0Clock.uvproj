# Keil uVision project Timer0Clock.uvproj, settings and files
target Fs_Timer0Clock (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Timer0Clock +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\FsBSP\inc;..\FsBSP\src;..\STCLib;..\USER
  group USER
    ./: STARTUP.A51
    ../USER/: main.c
  group FsBSP
    ../FsBSP/src/: FsBSP_Timer.c
