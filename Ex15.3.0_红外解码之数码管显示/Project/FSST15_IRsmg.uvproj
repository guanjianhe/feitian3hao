# Keil uVision project FSST15_IRsmg.uvproj, settings and files
target FSST15_IRsmg (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: FSST15_IRsmg +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\FsBSP\src;..\FsBSP\inc;..\STCLib\inc;..\STCLib\src;..\USER
  link misc: REMOVEUNUSED
  group FsBSP
    ../FsBSP/src/: FsBSP_HC595.c
  group STCLib
    ../STCLib/src/: stc15_exti.c stc15_gpio.c stc15_timer.c stc15_delay.c
  group USER
    ../USER/: main.c
  group Doc
    ../: 说明.txt
