# Keil uVision project FS15_MultifunctionalRadio.uvproj, settings and files
target FSST15_MultifunctionalRadio (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: FS15_MultifunctionalRadio +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\FsBSP\inc;..\FsBSP\src;..\STCLib\inc;..\STCLib\src;..\USER
  link misc: REMOVEUNUSED
  group FsBSP
    ../FsBSP/src/: FsBSP_1602.c FsBSP_LM75A.c FsBSP_PCF8563T.c FsBSP_RDA5807M.c
  group STCLib
    ../STCLib/src/: stc15_delay.c stc15_gpio.c stc15_iic.c
  group USER
    ../USER/: main.c
  group Doc
    ../: 说明.txt
