# Keil uVision project FSST15_AT24C02.uvproj, settings and files
target FSST15_AT24C02 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: FSST15_AT24C02 +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\STCLib\inc;..\STCLib\src;..\USER
  link misc: REMOVEUNUSED
  group STCLiB
    ../STCLib/src/: stc15_gpio.c stc15_delay.c stc15_iic.c stc15_usart.c
  group USER
    ../USER/: main.c
  group Doc
    ../: 说明.txt
