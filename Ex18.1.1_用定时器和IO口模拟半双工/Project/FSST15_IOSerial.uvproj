# Keil uVision project FSST15_IOSerial.uvproj, settings and files
target FSST15_ioSerial (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: FSST15_IOSerial +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\FsBSP\inc;..\FsBSP\src;..\STCLib\inc;..\STCLib\src;..\USER
  link misc: REMOVEUNUSED
  group STCLib
    ../STCLib/src/: stc15_timer.c stc15_delay.c
  group USER
    ../USER/: main.c
  group Doc
    ../: 说明.txt
