# Keil uVision project PWM_Speed_Demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: PWM_Speed_Demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\FsBSP\inc;..\FsBSP\src;..\Project;..\STCLib\inc;..\STCLib\src;..\USER
  group Project
    ./: STARTUP.A51
  group STCLib
    ../STCLib/inc/: STC15.H
  group FsBSP
    ../FsBSP/src/: FsBSP_PWM.c FsBSP_Delay.c
  group USER
    ../USER/: main.c
