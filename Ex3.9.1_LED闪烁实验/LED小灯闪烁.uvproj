# Keil uVision project LED小灯闪烁.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: LED小灯闪烁 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: LED小灯闪烁.c
