# Keil uVision project Fs_KeySMG.uvproj, settings and files
target Fs_KeySMG (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Fs_KeySMG +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\FsBSP\inc;..\FsBSP\src;..\USER
  group FsBSP
    ../FsBSP/src/: FsBSP_HC595.c FsBSP_Delay.c
  group USER
    ../USER/: main.c
  group Doc
    ../: 说明.txt
