/* ****************************** 作者：残弈悟恩 *****************************************
 * 文件名称 : main.c
 * 文件描述 : 点阵屏的基本应用实例
 * 硬件平台 ：飛天三號 FSST15实验板
 * 软件环境 ：Keil uVision5.13
 * 
 * 版本代号	: V1.0 	   					
 * 修改日期	: 2015-09-04
 * 技术论坛 ：电子工程师基地（http://www.ieebase.net）
 * 淘宝店铺 ：http://fsmcu.taobao.com
 * 例程说明 ：本例程为教材《与STC15单片机牵手的那些年》（清华大学出版社）配套例程
			  为视频《深入浅出玩转STC15单片机》配套例程（录制100讲--西安：愚公）
			  视频和书籍均被STC（深圳宏晶科技）官方大学计划和高校高性能联合实验室权威推荐

 * Copyright (C), 2013-2015, 兰州文轩电子科技有限公司/清华大学出版社
 
 * 仅供学习使用，未经作者许可，不得用于其它商业用途，盗版必究。
************************************************************************************** */

#include "FsBSP_LedScreen.h"
#include "FsBSP_Delay.h"

/* ***************************************************** */
// 控制数组定义
/* ***************************************************** */
/* *******说明(选择列所用的数组)****************
*1.最低位控制第一列
*2.该数组的意思是从第一列开始，依次选中第1...8列
********************************************* */
uChar8 code ColArr[8] = {0xfe,0xfd,0xfb,0xf7,0xef,0xdf,0xbf,0x7f};
/* ********心图案1******************************
* 该数组用于存储图案
* 取摸方式 纵向取摸 方式：由下到上
********************************************* */
uChar8 code RowArr1[32][8] = {
{0x80,0x42,0x24,0x18,0x18,0x24,0x42,0x80},
{0x42,0x24,0x18,0x18,0x24,0x42,0x80,0x00},
{0x24,0x18,0x18,0x24,0x42,0x80,0x00,0x00},
{0x18,0x18,0x24,0x42,0x80,0x00,0x00,0x82},
{0x18,0x24,0x42,0x80,0x00,0x00,0x82,0xFE},
{0x24,0x42,0x80,0x00,0x00,0x82,0xFE,0xFE},
{0x42,0x80,0x00,0x00,0x82,0xFE,0xFE,0x82},
{0x80,0x00,0x00,0x82,0xFE,0xFE,0x82,0x00},
{0x00,0x00,0x82,0xFE,0xFE,0x82,0x00,0x00},
{0x00,0x82,0xFE,0xFE,0x82,0x00,0x00,0x1C},
{0x82,0xFE,0xFE,0x82,0x00,0x00,0x1C,0x22},
{0xFE,0xFE,0x82,0x00,0x00,0x1C,0x22,0x42},
{0xFE,0x82,0x00,0x00,0x1C,0x22,0x42,0x84},
{0x82,0x00,0x00,0x1C,0x22,0x42,0x84,0x84},
{0x00,0x00,0x1C,0x22,0x42,0x84,0x84,0x42},
{0x00,0x1C,0x22,0x42,0x84,0x84,0x42,0x22},
{0x1C,0x22,0x42,0x84,0x84,0x42,0x22,0x1C},
{0x1C,0x3E,0x7E,0xFC,0xFC,0x7E,0x3E,0x1C},//重复心形，停顿效果
{0x1C,0x3E,0x7E,0xFC,0xFC,0x7E,0x3E,0x1C},
{0x22,0x42,0x84,0x84,0x42,0x22,0x1C,0x00},
{0x42,0x84,0x84,0x42,0x22,0x1C,0x00,0x00},
{0x84,0x84,0x42,0x22,0x1C,0x00,0x00,0x7E},
{0x84,0x42,0x22,0x1C,0x00,0x00,0x7E,0xFE},
{0x42,0x22,0x1C,0x00,0x00,0x7E,0xFE,0xC0},
{0x22,0x1C,0x00,0x00,0x7E,0xFE,0xC0,0xC0},
{0x1C,0x00,0x00,0x7E,0xFE,0xC0,0xC0,0xFE},
{0x00,0x00,0x7E,0xFE,0xC0,0xC0,0xFE,0x7E},
{0x00,0x7E,0xFE,0xC0,0xC0,0xFE,0x7E,0x00},
{0x00,0x7E,0xFE,0xC0,0xC0,0xFE,0x7E,0x00},//重复U，产生停顿效果
{0x00,0x7E,0xFE,0xC0,0xC0,0xFE,0x7E,0x00},//若要停顿时间长，多重复几次即可
{0x00,0x7E,0xFE,0xC0,0xC0,0xFE,0x7E,0x00},
{0x00,0x7E,0xFE,0xC0,0xC0,0xFE,0x7E,0x00}
};

/* ***************************************************** */
// 函数名称：main()
// 函数功能：显示数组中的点阵数据，进而显示I LOVE YOU
// 入口参数：无
// 出口参数：无
/* ***************************************************** */
void main(void)
{ 
	while(1)
	{
		unsigned char i,j;
		for(i=0;i<32;i++)
			for(j=0;j<8;j++)
		{
			LedScreen_WrTwoByte(ColArr[j],RowArr1[i][j]);
			DelayMS(3);
			LedScreen_WrTwoByte(ColArr[j],RowArr1[i][j]);
			DelayMS(3);
			LedScreen_WrTwoByte(ColArr[j],RowArr1[i][j]);
			DelayMS(3);			
			LedScreen_WrTwoByte(ColArr[j],RowArr1[i][j]); 
			DelayMS(3);
			LedScreen_WrTwoByte(ColArr[j],RowArr1[i][j]); 
			DelayMS(3);
			LedScreen_WrTwoByte(ColArr[j],RowArr1[i][j]); 
			DelayMS(3);
			LedScreen_WrTwoByte(ColArr[j],RowArr1[i][j]); 
			DelayMS(3);
			LedScreen_WrTwoByte(ColArr[j],RowArr1[i][j]);
			DelayMS(3);
		}
		DelayMS(600);
	}
}
/* *********************************** End of File *********************************** */
